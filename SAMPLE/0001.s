ROM		EQU		8000H		;ROM STARTING ADDRESS
PIOAD	EQU		0D0h		;PIO A DATA
PIOAC	EQU		0D1h		;PIO A CONTROL
PIOBD	EQU		0D2h		;PIO B DATA
PIOBC	EQU		0D3h		;PIO B CONTROL
SYS		EQU		0D8H		;SYSTEM CONTROL
INT		EQU		0D9h		;SYSTEM MNI PORT
MODE	EQU		07CCh		;USER PROGRAM MODE
STACK	EQU		07CCh		;MONITOR STACK
USER	EQU		079Ah		;USER STACK
SEGBUF	EQU		07CDh		;SEGMENT BUFFER
DISBUF	EQU		07D5h		;DISPLAY BUFFER
FLAG	EQU		07DDh		;CHATTERING FLAG
DATA	EQU		07DFh		;DATA REG.
ADDR	EQU		07E1h		;ADDRESS REG.
SAVE	EQU		07E3h		;USER REG. SAVE AREA
BCOUNT	EQU		07FDh		;BREAK COUNTER
BADDR	EQU		07FEh		;BREAK ADDRESS
DISP1	EQU		8436h
DISP2	EQU		843bh
SEGCON	EQU		8465h
KEYIN	EQU		8482h
SCAN	EQU		84C3h

		ORG		0000h

START:
		LD		DE,DATA01
ST1:	LD		A,(DE)
		CP		0FFH
		JR		Z,START
		CALL	DISP
		JR		ST1
		

DISP:
		LD		B,8
		LD		HL,SEGBUF+7
LP1:	LD		A,(DE)
		LD		(HL),A
		DEC		HL
		INC		DE
		DJNZ	LP1
		CALL	WAIT
		RET

WAIT:
		PUSH	HL
		PUSH	DE
		PUSH	BC
		PUSH	AF
		LD		B,10H
W1:
		CALL	SCAN
		DJNZ	W1
		POP		AF
		POP		BC
		POP		DE
		POP		HL
		RET
		
DATA01:
		DB		01h,00h,00h,00h,00h,00h,00h,00h
		DB		00h,01h,00h,00h,00h,00h,00h,00h
		DB		00h,00h,01h,00h,00h,00h,00h,00h
		DB		00h,00h,00h,01h,00h,00h,00h,00h
		DB		00h,00h,00h,00h,01h,00h,00h,00h
		DB		00h,00h,00h,00h,00h,01h,00h,00h
		DB		00h,00h,00h,00h,00h,00h,01h,00h
		DB		00h,00h,00h,00h,00h,00h,00h,01h
		DB		00h,00h,00h,00h,00h,00h,00h,02h
		DB		00h,00h,00h,00h,00h,00h,00h,04h
		DB		00h,00h,00h,00h,00h,00h,00h,08h
		DB		00h,00h,00h,00h,00h,00h,08h,00h
		DB		00h,00h,00h,00h,00h,08h,00h,00h
		DB		00h,00h,00h,00h,08h,00h,00h,00h
		DB		00h,00h,00h,08h,00h,00h,00h,00h
		DB		00h,00h,08h,00h,00h,00h,00h,00h
		DB		00h,08h,00h,00h,00h,00h,00h,00h
		DB		08h,00h,00h,00h,00h,00h,00h,00h
		DB		10h,00h,00h,00h,00h,00h,00h,00h
		DB		20h,00h,00h,00h,00h,00h,00h,00h
		DB		0FFh,0FFh,0FFh,0FFh,0FFh,0FFh,0FFh,0FFh

		END
